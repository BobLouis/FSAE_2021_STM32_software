<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\buzzer_TIM1_CH1.ewp</path>
  </project>
  <batchBuild />
</workspace>
